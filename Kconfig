## Kconfig
```kconfig
menu "vglite"
    config MCUX_COMPONENT_middleware.vglite
        bool "GPU VGLite library"
endmenu
```
